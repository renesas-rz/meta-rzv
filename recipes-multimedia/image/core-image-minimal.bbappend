require include/core-image-renesas-mmp-base.inc
