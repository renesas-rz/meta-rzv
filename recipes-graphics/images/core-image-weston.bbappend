require include/core-image-renesas-base.inc
require include/core-image-renesas-mmp.inc
require include/core-image-sdk.inc

IMAGE_INSTALL_append = " opencv opencv-dev "
